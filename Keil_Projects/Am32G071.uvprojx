# Keil uVision project Am32G071.uvprojx, settings and files
target GEN_64K_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AM32_GEN_64K_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GEN_64K_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: ..\Mcu\g071\Drivers\CMSIS\Include;..\Mcu\g071\Drivers\STM32G0xx_HAL_Driver\Inc;..\Mcu\g071\Drivers\CMSIS\Device\ST\STM32G0xx\Include;..\Mcu\g071\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
  group startup
    ../Mcu/g071/Startup/mdk/: startup_stm32g071xx.s
  group g071
    ../Mcu/g071/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32g0xx_it.c system_stm32g0xx.c WS2812.c
    ../Src/: kiss_telemetry.c
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c
  group Drivers
    ../Mcu/g071/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
target DT120_64K_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_DT120_64K_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DT120_64K_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target NEUTRONRC_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_NEUTRONRC_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NEUTRONRC_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target IFLIGHT_BLITZ_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_IFLIGHT_BLITZ_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IFLIGHT_BLITZ_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target AIKON_PRO_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_AIKON_PRO_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AIKON_PRO_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target TMOTOR_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_TMOTOR_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TMOTOR_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target SEQURE_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_SEQURE_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SEQURE_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target HAKRC_2023_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_HAKRC_2023_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HAKRC_2023_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target SEQURE_12S_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_SEQURE_12S_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SEQURE_12S_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target FLYCOLOR_HV3_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_FLYCOLOR_HV3_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLYCOLOR_HV3_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target AORC_GP_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_AORC_GP_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AORC_GP_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target AORC_PD_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_AORC_PD_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AORC_PD_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target IFLIGHT_12S_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_IFLIGHT_12S_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IFLIGHT_12S_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target IFLIGHT_BLITZ_N_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_IFLIGHT_BLITZ_N_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IFLIGHT_BLITZ_N_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target SEQURE_4IN1_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_SEQURE_4IN1_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SEQURE_4IN1_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target NEUTRON_PULLUP_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_NEUTRON_PULLUP_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NEUTRON_PULLUP_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target AM32_ESC_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_ESC_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM32_ESC_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target IFLIGHT_12S_SINGLE_N_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_IFLIGHT_12S_SINGLE_N_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: IFLIGHT_12S_SINGLE_N_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target ST_G0_03_N_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_ST_G0_03_N_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ST_G0_03_N_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target ST_G0_04_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_ST_G0_04_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ST_G0_04_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target SURFBEE_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_SURFBEE_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SURFBEE_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target RRIOT_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_RRIOT_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RRIOT_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
target TBS_4IN1_G071 (6240000::V6.24::ARMCLANG)
  device: STM32G071K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: as above
  output: AM32_TBS_4IN1_G071 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TBS_4IN1_G071,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\Mcu\g071\Am32_64kb_g071.sct
